options:
  parameters:
    author: helmick
    generate_options: qt_gui
    id: experiment
    output_language: python
    title: experiment
  states: {}

blocks:
- name: finetune
  id: variable_qtgui_range
  parameters:
    label: Fine Tune
    orient: Qt.Horizontal
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: rfsamp
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: squ
  id: variable_qtgui_range
  parameters:
    label: VOX
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: transmit_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '432100000'
    step: '500'
    stop: '438000000'
    value: '432200000'
  states: {}
- name: usbswitch
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: USB
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squ
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '.5'
    high_cutoff_freq: '2400'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: firdes.WIN_HANN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: usbswitch
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-usbswitch
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '4000'
    win: firdes.WIN_HANN
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"device=''HackRF'',driver=hackrf,part_id=a000cb3c005f4f5f,serial=0000000000000000644064dc367c9dcd,soapy=3,version=2018.01.1"'
    bb_gain0: '20'
    freq0: transmit_freq+finetune
    gain0: '0'
    if_gain0: '0'
    sample_rate: rfsamp
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rfsamp/samp_rate)
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [blocks_add_xx_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_complex_to_magphase_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_const_vxx_1, '0']
- [hilbert_fc_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
