options:
  parameters:
    author: helmick
    generate_options: qt_gui
    id: experiment
    output_language: python
    title: experiment
  states: {}

blocks:
- name: rfsamp
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: usbswitch
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: USB
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '.5'
    high_cutoff_freq: '2400'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HANN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: usbswitch
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-usbswitch
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '4000'
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-200'
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_complex_to_magphase_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_const_vxx_1, '0']
- [hilbert_fc_0, '0', blocks_multiply_const_vxx_1_1, '0']

metadata:
  file_format: 1
