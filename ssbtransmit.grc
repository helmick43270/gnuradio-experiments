options:
  parameters:
    author: helmick
    generate_options: qt_gui
    id: ssbtransmit
    output_language: python
    title: ssbtransmit
  states: {}

blocks:
- name: finetune
  id: variable_qtgui_range
  parameters:
    label: Clarify
    orient: Qt.Horizontal
    start: '-300'
    step: '1'
    stop: '300'
    value: '0'
  states: {}
- name: rfsamp
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: transmit_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '144100000'
    step: '500'
    stop: '144400000'
    value: '144190000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2.4'
    high_cutoff_freq: '2400'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: firdes.WIN_HANN
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '4000'
    win: firdes.WIN_HANN
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"device=''HackRF'',driver=hackrf,part_id=a000cb3c005f4f5f,serial=0000000000000000644064dc367c9dcd,soapy=3,version=2018.01.1"'
    bb_gain0: '0'
    freq0: transmit_freq+finetune
    gain0: '0'
    if_gain0: '0'
    sample_rate: rfsamp
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(rfsamp/samp_rate)
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
